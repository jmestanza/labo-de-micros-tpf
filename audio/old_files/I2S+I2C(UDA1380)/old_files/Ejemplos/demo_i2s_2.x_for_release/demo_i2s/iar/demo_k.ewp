# IAR project demo_k.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: D:\work\prj\g_demo_k\demo_k\src\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo_k.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: D:\work\AN\my AN\I2S\code2.x\demo_i2s_p2r2\demo_i2s\iar\icf\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: entry
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../src/: main.c
  group app
    ../src/app/: app_audio.c
  group hal
    ../src/hal/: hal.c hal_audio.c hal_clock.c hal_dma.c hal_i2c.c hal_i2s.c hal_int.c hal_uart.c hal_watchdog.c nvic.c
  group hw
    ../src/hw/: hw_audio_sgtl5000.c
  group lib
    ../src/lib/: q_printf.c
